NAOS_RELEASE_IMAGE:radxa-airbox-q900 = "naos-qcom-image"
NAOS_RELEASE_OTA_TASKS:radxa-airbox-q900 = "naos-qcom-bundle:do_build"
